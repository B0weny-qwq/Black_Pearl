# Keil uVision project remoteShip.uvproj, settings and files
target GPS_V13 (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: remoteShip +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver\Inc;.\App\Config;.\App\DcMotor;.\App\Led;.\App\Timer;.\App\Interrupt;.\App\PWM;.\App\Utils;.\App\Wireless\LT8920;.\App\Wireless;.\App\Gyro;.\App\Gps;.\App\AutoDrive;.\App\ADC;.\App\eeprom
  group Source Group 1
    ./: STARTUP.A51
  group Driver
    ./Driver/Src/: STC8G_H_GPIO.c STC8G_H_Delay.c STC8H_PWM.c STC8G_H_Soft_I2C.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_EEPROM.c STC8G_H_UART.c STC8G_H_ADC.c
  group DcMotor
    ./App/DcMotor/: DcMotor_Gpio.c
  group Led
    ./App/Led/: led.c
  group Main
    ./App/Main/: main.c
    ./App/AutoDrive/: autoDrive.c
  group Wireless
    ./App/Wireless/LT8920/: LT8920_SPI.c
    ./App/Wireless/: wirelessProtocal.c
  group Timer
    ./App/Timer/: timer.c
  group Interrupt
    ./App/Interrupt/: interrupt.c
  group Pwm
    ./App/PWM/: pwm.c pwm_Gpio.c pwm_Speed.c
  group Utils
    ./App/Utils/: utils_printf.c utils_encodingTransfer.c utils_splitString.c utils_checkSum.c
  group Gps
    ./App/Gps/: gps_uart.c nmea41_protocal.c
  group Adc
    ./App/ADC/: adc_config.c power_Adc.c
  group Eeprom
    ./App/eeprom/: eeprom.c
  group compass
    ./App/compass/: compass.c qmc5833.c qmc5883p.c qmc6309.c
target GPS_V16_MID (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: ship_gps_6309 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: HW_V16,MID_SHIP,MAG_QMC_6309
  c include: .\Driver\Inc;.\App\Config;.\App\DcMotor;.\App\Led;.\App\Timer;.\App\Interrupt;.\App\PWM;.\App\Utils;.\App\Wireless\LT8920;.\App\Wireless;.\App\Gyro;.\App\Gps;.\App\AutoDrive;.\App\ADC;.\App\eeprom;.\App\compass
target GPS_V16_5883P (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: mid_ship_gps_6309_0314 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: HW_V16,MID_SHIP,MAG_QMC_6309,GPS_DK2_RMC
  c include: as above
target GPS_V16_12V (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: ship_gps_12v +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: HW_V16,SHIP_MID,BOARD_12V,MAG_QMC_5883P
  c include: as above
