# Keil uVision project STC32G-LIB.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G-LIB +hex
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c system_init.c Task.c MainLoop.c isr.asm
  group APP
    ../App/src/: APP.c APP_AD_UART.c APP_Lamp.c APP_INT_UART.c APP_RTC.c APP_I2C_PS.c APP_SPI_PS.c APP_WDT.c APP_EEPROM.c APP_DMA_AD.c APP_DMA_LCM.c APP_DMA_M2M.c APP_DMA_SPI_PS.c APP_DMA_UART.c APP_PWMA_Output.c APP_PWMB_Output.c APP_DMA_I2C.c APP_CAN.c APP_LIN.c APP_USART_LIN.c APP_USART2_LIN.c APP_HSSPI.c APP_HSPWM.c
  group Driver
    ../Driver/src/: STC32G_ADC.c STC32G_Compare.c STC32G_Delay.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_NVIC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_WDT.c STC32G_DMA.c STC32G_PWM.c STC32G_RTC.c STC32G_CAN.c STC32G_LIN.c STC32G_Clock.c STC32G_USART_LIN.c
  group ISR
    ../Driver/isr/: STC32G_ADC_Isr.c STC32G_Compare_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c STC32G_DMA_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_LCM_Isr.c STC32G_CAN_Isr.c STC32G_LIN_Isr.c
  group QMC6309
    ../Code_boweny/Device/QMC6309/: QMC6309.c QMC6309.h QMC6309_port.c QMC6309_port.h
  group QMI8658
    ../Code_boweny/Device/QMI8658/: QMI8658.c QMI8658.h QMI8658_port.c QMI8658_port.h
  group GPS
    ../Code_boweny/Device/GPS/: GPS.c GPS.h
  group WIRELESS
    ../Code_boweny/Device/WIRELESS/: wireless.c lt8920.c wireless_port.c ship_protocol.c wireless.h lt8920.h wireless_port.h ship_protocol.h
  group MOTOR
    ../Code_boweny/Device/MOTOR/: Motor.c Motor.h
  group AutoDrive
    ../Code_boweny/Device/AutoDrive/: autodrive.c autodrive_cfg.c autodrive.h autodrive_cfg.h
  group LOG
    ../Code_boweny/Function/Log/: Log.c Log.h
  group FILTER
    ../Code_boweny/Function/Filter/: Filter.c Filter.h
  group AHRS
    ../Code_boweny/Function/AHRS/: AHRS.c AHRS.h HeadingEstimator.c HeadingEstimator.h
  group PID
    ../Code_boweny/Function/PID/: PID.c PID.h
  group LIB
    ../Driver/lib/: STC32_MDU32_HUGE.LIB STC32_MDU32_LARGE.LIB
